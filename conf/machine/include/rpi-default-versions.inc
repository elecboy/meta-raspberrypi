## conf/machine/include/rpi-default-versions.inc
```bitbake
# RaspberryPi BSP default versions

PREFERRED_VERSION_linux-raspberrypi ??= "4.14.%"
PREFERRED_VERSION_libgfortran ?= "linaro-6.3%"
```
